# Keil uVision project project.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER=STM32F10X_MD
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\Startup;.\User;.\Basic\Delay;.\Basic\usart;.\Hardware\RFID;.\Basic\sys;.\Basic\timer;.\Hardware\LED;.\Basic\SPI;.\Basic\adc;.\Basic\iic;.\Hardware\control;.\Hardware\encoder;.\Hardware\motor;.\Hardware\mpu;.\Hardware\oled;.\Hardware\pid;.\Hardware\track;.\Basic\gpio
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c
  group Basic
    ./Basic/Delay/: delay.c
    ./Basic/usart/: usart.c
    ./Basic/sys/: sys.c
    ./Basic/timer/: timer.c
    ./Basic/iic/: bsp_iic.c
    ./Basic/SPI/: spi.c
    ./Basic/adc/: myadc.c
    ./Basic/gpio/: mygpio.c
  group Hardware
    ./Hardware/RFID/: rc522.c
    ./Hardware/LED/: led.c
    ./Hardware/oled/: bsp_oled.c
    ./Hardware/track/: track.c
    ./Hardware/control/: control.c
    ./Hardware/pid/: pid.c
    ./Hardware/encoder/: encoder.c
    ./Hardware/motor/: motor.c
